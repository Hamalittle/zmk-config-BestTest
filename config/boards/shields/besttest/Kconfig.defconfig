## config/boards/shields/besttest/Kconfig.defconfig
```kconfig
if SHIELD_BESTTEST
    config ZMK_KEYBOARD_NAME
        default "besttest"
endif
```
